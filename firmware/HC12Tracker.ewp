# IAR project HC12Tracker.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: energy.c energy.h fix.h gps.c gps.h HC12Board.h main.c main.h pips.h rtty.c rtty.h si_trx.c si_trx.h si_trx_defs.h spi_bitbang.c spi_bitbang.h number_format.c number_format.h telemetry.c telemetry.h
